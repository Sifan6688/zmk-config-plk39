## config/boards/shields/plk39/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_plk39
    def_bool $(shields_list_contains,plk39)
```
